TYPE T_Buffer: ARRAY[0..MAX_CSV_ROWS, 0..MAX_CSV_COLUMNS ] OF STRING(MAX_CSV_FIELD_LENGTH); (* [] (* TODESC *) *)
END_TYPE
