TYPE ST_Buffer :
STRUCT
	bFull 		: BOOL;
	sPath		: STRING;
	aBuffer 	: ARRAY[0..MAX_CSV_ROWS, 0..MAX_CSV_COLUMNS ] OF STRING(MAX_CSV_FIELD_LENGTH) ;
	fbWriter 	: FB_Writer;
END_STRUCT
END_TYPE
